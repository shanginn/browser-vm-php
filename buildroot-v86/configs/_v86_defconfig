## buildroot-v86/package/psysh/Config.in
```kconfig
config BR2_PACKAGE_PSYSH
	bool "psysh"
	help
	  A runtime developer console, interactive debugger and REPL for PHP https://psysh.org/
```
